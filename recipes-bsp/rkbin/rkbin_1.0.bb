DESCRIPTION = "Rockchip binary tools"

SRC_URI = "git://github.com/rockchip-linux/rkbin.git;branch=master;protocol=https"