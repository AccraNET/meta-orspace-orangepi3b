DEPENDS += "trusted-firmware-a"
PREFERRED_VERSION_truted-firmware-a = "2.13.0"

